DESCRIPTION = "Minimal image with X11, GStreamer and 3D and video decoding acceleration drivers added"

include ar802-demo-image.inc

